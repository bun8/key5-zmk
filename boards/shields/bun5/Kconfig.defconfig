## boards/shields/bun5/Kconfig.defconfig
```kconfig
if SHIELD_BUN5

config ZMK_KEYBOARD_NAME
    default "bun5"

endif # SHIELD_BUN5
```
